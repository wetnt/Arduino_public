#include <SoftwareSerial.h>
SoftwareSerial myCmd(10, 11); // RX, TX

void setup()
{
  Serial.begin(9600);
  myCmd.begin(9600);
  while (!Serial) {}
  Serial.println("BBK_CMD_ok");
}




//-------------------------------------------------------------------------
void loop() 
{
  //-------------------------------------------------------------------------
  SerialRead();
  //-----------------------------
  CmdRead();
  //-------------------------------------------------------------------------
}

void SerialRead()
{
  //-------------------------------------------------------------------------
  while (Serial.available()>0)
  {
    SerialExp(Serial.read());    
  }
  //-------------------------------------------------------------------------
}

void CmdRead()
{
  //-------------------------------------------------------------------------
  while (myCmd.available()>0)
  {
    //SerialExp(myCmd.read());    
  }
  //-------------------------------------------------------------------------
}
